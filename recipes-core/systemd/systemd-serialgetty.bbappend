SERIAL_CONSOLES:append = " 115200;ttyGS0"
